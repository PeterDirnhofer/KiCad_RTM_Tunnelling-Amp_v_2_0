# Repository PeterDirnhofer/KiCad_RTM_Tunnelling-Amp_v_2_0

File README.md:

# PeterDirnhofer-KiCad_RTM_Tunnelling-Amp_v_2_0
500 EURO RTM KiCad Tunneling Amplifier

## KiCad design Tunnelling-Amp.kicad_pcb

Parts:
C1, C2: 47n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 4u7; CP_EIA-6032-15_Kemet-U; Digikey 478-1737-1-ND
C6: 4u7; CP_EIA-6032-15_Kemet-U
J1: RF_Shield_Two_Pieces; Laird_Technologies_BMI-S-201-F_13.66x12.70mm; Digikey 903-1006-1-ND or 903-1050-1-ND + 903-10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
R1: 100MEG; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Digikey 13-RC1206JR-07100MLCT-ND
TIP1: IN; TestPoint_Pad_2.5x2.5mm
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_D1.5mm
U1: ADA4637-1; SOIC-8_3.9x4.9mm_P1.27mm; Digikey ADA4637-1ARZ-ND

Connections:
+15V: C1.1, C3.1, C5.1, TP2.1, U1.7 (V+)
-15V: C2.2, C4.2, C6.2, TP4.1, U1.4 (V-)
/in: R1.2, TIP1.1, U1.2 (-)
/out: R1.1, TP5.1, U1.6
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.1, J1.1 (Shield), TP1.1, TP3.1, TP6.1, U1.3 (+)

Board: 2 copper layers, 30.0 x 19.0 mm, 16 parts (0 on the bottom side), 5 nets.

## Commit log

2025-02-13 1st commit
2025-02-13 update KiCad8
2025-03-07 'OPA227'
